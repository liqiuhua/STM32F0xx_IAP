# Keil uVision project stm32f030Bootlader.uvprojx, settings and files
target bootlader (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F030C8Tx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: stm32f030Bootlader +hex
  AfterMake: fromelf --bin !L --output stm32f030Bootlader.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F0XX,__CC_ARM
  c include: .\Libraries\STM32F0xx_StdPeriph_Driver\inc;.\Libraries\STARTUP;.\User
  library: MicroLIB
  memory RVCT4: ROM 0x8003000 size 0x10000
  memory RVCT9: RAM 0x200000c0 size 0x1f40
  group STARTUP
    ./Libraries/STARTUP/: startup_stm32f0xx.s
  group DRIVERS
    ./Libraries/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_adc.c stm32f0xx_crc.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_wwdg.c
  group USER
    ./User/: stm32f0xx_it.c main.c system_stm32f0xx.c bootlader.c
